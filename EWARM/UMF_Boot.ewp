# IAR project UMF_Boot.ewp, settings and files
configuration UMF_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ../Boot/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UMF_Boot.hex
  ILINK.IlinkOutputFile: UMF_Boot.out
  ILINK.IlinkIcfFile: UMF_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../Boot/Src/: main.c bl_crc.c
  group EWARM
    ./: startup_stm32f103xb.s
